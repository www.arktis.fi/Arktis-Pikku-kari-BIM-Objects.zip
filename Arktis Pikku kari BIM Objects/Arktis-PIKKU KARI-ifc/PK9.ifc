Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: cd8dc424-a657-4fbe-a95f-49771cec3117, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates]
File name: PK9.ifc
Time: 2026-10-18T23:04:45+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.90.15 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcFurnishingElement: PK9:PK9, PK9:PK9:356735
In: Level 1
Type - Material: Default Metal, Birch, Natural, Light grey, Green Laminate
Type - Pset_FurnitureTypeCommon - Description: PikkuKari5, 35cm Seat Height
Type - Pset_ManufacturerTypeInformation - Manufacturer: Arktis
Pset_QuantityTakeOff - Reference: PK9
