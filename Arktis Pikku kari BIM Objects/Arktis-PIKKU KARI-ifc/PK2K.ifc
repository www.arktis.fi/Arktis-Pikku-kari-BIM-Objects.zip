Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: d2dfd5ca-b30d-4087-8dd1-ca7e1e26f46a, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates]
File name: PK2K.ifc
Time: 2026-10-18T22:59:55+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.90.15 (ENU) - IFC 23.4.1.0

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcFurnishingElement: PK2K:PK2K, PK2K:PK2K:351593
In: Level 1
Type - Material: Default Metal, Birch, Natural, Red Plywood, Light grey
Type - Pset_FurnitureTypeCommon - Description: PikkuKari2, 22cm Seat Height
Type - Pset_ManufacturerTypeInformation - Manufacturer: Arktis
Pset_QuantityTakeOff - Reference: PK2K
